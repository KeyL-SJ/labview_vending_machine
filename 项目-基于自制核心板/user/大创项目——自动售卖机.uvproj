# Keil uVision project 大创项目——自动售卖机.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 大创项目——自动售卖机 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\sys;..\driver
  group User
    ./: main.c
  group Sys
    ../sys/: usart.c Timer.c
  group Driver
    ../driver/: key.c iic.c
