# Keil uVision project speech.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: speech +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\语音播报教程
  group 源代码组 1
    ./: main.c
